DO Lauterbach/common.cmm